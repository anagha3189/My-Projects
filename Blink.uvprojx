# Keil uVision project Blink.uvprojx, settings and files
target TM4C123GH6PM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blink
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\ti\TivaWare_C_Series-2.1.4.178\inc;C:\ti\TivaWare_C_Series-2.1.4.178\driverlib;C:\ti\TivaWare_C_Series-2.1.4.178
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c Led_Task.c UART_Task.c Switch_Task.c
  group Include
    ./: Led_Task.h UART_Task.h Switch_Task.h
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Coroutines 10.0.1, RTOS:Event Groups 10.0.1, RTOS:Heap 10.0.1, RTOS:Message Buffer 10.0.1, RTOS:Stream Buffer 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, CMSIS:RTOS2:FreeRTOS 10.0.1, Device:Startup 1.0.1
